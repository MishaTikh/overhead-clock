#include "render.h"

#include <ctype.h>
#include <math.h>
#include <stdio.h>

#include "config.h"
#include "overhead.h"

namespace ov {

// Classic 5x7 font, ASCII 0x20..0x5A, column-major, LSB = top row.
static const uint8_t BIG[][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x00,0x07,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x2A,0x1C,0x7F,0x1C,0x2A},{0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x80,0x60,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4D,0x33},
    {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
    {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1E},{0x00,0x00,0x14,0x00,0x00},{0x00,0x40,0x34,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},
    {0x3E,0x41,0x5D,0x59,0x4E},{0x7C,0x12,0x11,0x12,0x7C},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x41,0x3E},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x41,0x51,0x73},
    {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x1C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x26,0x49,0x49,0x49,0x32},
    {0x03,0x01,0x7F,0x01,0x03},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4D,0x43},
};

static char fold(char c) {
    unsigned char u = (unsigned char)c;
    if (u >= 'a' && u <= 'z') return (char)(u - 32);
    if (u < 0x20 || u > 0x5A) return '?';
    return (char)u;
}

// strip UTF-8 accents crudely: drop continuation bytes, map lead byte to '?'-free fallback
static std::string ascii(const std::string& s) {
    std::string o;
    for (size_t i = 0; i < s.size(); i++) {
        unsigned char c = s[i];
        if (c < 0x80) { o += (char)c; continue; }
        if (c == 0xC3 && i + 1 < s.size()) {  // Latin-1 supplement: map common accented letters
            unsigned char d = s[++i];
            const char* map = "AAAAAAACEEEEIIIIDNOOOOOxOUUUUYPsaaaaaaaceeeeiiiidnooooo/ouuuuypy";
            if (d >= 0x80 && d <= 0xBF) o += map[d - 0x80];
            continue;
        }
        while (i + 1 < s.size() && (((unsigned char)s[i + 1]) & 0xC0) == 0x80) i++;
    }
    return o;
}

std::vector<uint8_t> text_columns(const std::string& text) {
    std::vector<uint8_t> cols;
    for (char raw : ascii(text)) {
        char c = fold(raw);
        if (c == ' ') {
            cols.insert(cols.end(), 3, 0);
            continue;
        }
        const uint8_t* g = BIG[c - 0x20];
        int lo = 0, hi = 4;
        while (lo < 5 && !g[lo]) lo++;
        while (hi > lo && !g[hi]) hi--;
        if (lo >= 5) { lo = 0; hi = 0; }
        for (int x = lo; x <= hi; x++) cols.push_back(g[x]);
        cols.push_back(0);
    }
    if (!cols.empty() && cols.back() == 0) cols.pop_back();
    return cols;
}

void Marquee::set_text(const std::string& text, double now, float speed) {
    speed_ = speed;
    if (text == text_) return;
    text_ = text;
    t0_ = now;
    cols_ = text_columns(text);
}

// Always a big-letter marquee: show the start of the text, hold briefly, then scroll left and repeat.
double Marquee::seconds_for(int cycles) const {
    int n = (int)cols_.size();
    int cycle = n + 12 > MATRIX_W + 4 ? n + 12 : MATRIX_W + 4;
    return SCROLL_HOLD_S + cycles * (double)cycle / (speed_ > 0 ? speed_ : S.scroll_speed);
}

void Marquee::frame(double now, uint8_t* out) const {
    const int w = MATRIX_W, gap = 12;
    int n = (int)cols_.size();
    for (int i = 0; i < w; i++) out[i] = 0;
    if (!n) return;
    int cycle = n + gap > w + 4 ? n + gap : w + 4;   // short names still scroll fully off before repeating
    double t = now - t0_ - SCROLL_HOLD_S;
    int off = t > 0 ? ((int)(t * (speed_ > 0 ? speed_ : S.scroll_speed))) % cycle : 0;
    for (int i = 0; i < w; i++) {
        int k = (off + i) % cycle;
        out[i] = k < n ? cols_[k] : 0;
    }
}

}  // namespace ov

namespace ov {

// "9:45" (12 h) or "21:45" (24 h), big font, centered; colon blinks when colon_on is false.
void clock_frame(int hour24, int minute, bool colon_on, bool h24, uint8_t* out) {
    char hh[4], mm[4];
    int h = h24 ? hour24 : ((hour24 + 11) % 12 + 1);
    snprintf(hh, sizeof(hh), h24 ? "%02d" : "%d", h);
    snprintf(mm, sizeof(mm), "%02d", minute);
    std::vector<uint8_t> cols = text_columns(hh);
    cols.push_back(0);
    cols.push_back(colon_on ? 0x14 : 0x00);  // ':' column
    cols.push_back(0);
    std::vector<uint8_t> m = text_columns(mm);
    cols.insert(cols.end(), m.begin(), m.end());
    for (int i = 0; i < MATRIX_W; i++) out[i] = 0;
    int pad = ((int)MATRIX_W - (int)cols.size()) / 2;
    for (size_t i = 0; i < cols.size() && pad + (int)i < MATRIX_W; i++) out[pad + i] = cols[i];
}

}  // namespace ov
